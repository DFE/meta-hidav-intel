
PR_append = "+r0"
COMPATIBLE_MACHINE_cedartrail = "cedartrail"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_cedartrail = " file://static-kernel-version.patch "

