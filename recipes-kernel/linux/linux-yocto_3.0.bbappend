
require recipes-kernel/linux/linux-yocto-hidav.inc
